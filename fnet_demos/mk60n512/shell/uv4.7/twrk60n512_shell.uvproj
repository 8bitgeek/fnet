# Keil uVision project twrk60n512_shell.uvproj, settings and files
target K60N512 - 512KB Flash (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: shell_intflash
  c flags: Optim=4 OneElfS=1
  c include: ..\..\..\..\fnet_stack;..\..\..\..\fnet_stack\compiler;..\..\..\..\fnet_stack\cpu;..\..\..\..\fnet_stack\cpu\common;..\..\..\..\fnet_stack\cpu\mk;..\..\..\..\fnet_stack\os;..\..\..\..\fnet_stack\services;..\..\..\..\fnet_stack\services\dhcp;..\..\..\..\fnet_stack\services\dns;..\..\..\..\fnet_stack\services\flash;..\..\..\..\fnet_stack\services\fs;..\..\..\..\fnet_stack\services\http;..\..\..\..\fnet_stack\services\poll;..\..\..\..\fnet_stack\services\serial;..\..\..\..\fnet_stack\services\shell;..\..\..\..\fnet_stack\services\telnet;..\..\..\..\fnet_stack\services\tftp;..\..\..\..\fnet_stack\services\ping;..\..\..\..\fnet_stack\stack;.\src;..\..\..\common\fnet_application;..\..\..\common\startup\startup_mk60n512;..\..\..\common\startup\startup_mk60n512\common;..\..\..\common\startup\startup_mk60n512\drivers;..\..\..\common\startup\startup_mk60n512\headers
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x7f800
  memory RVCT5: ROM 0x7f800 size 0x800
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Linker Files\K60N512_FLASH.sct
  group fnet_stack
    ../../../../fnet_stack/compiler/: fnet_comp.h fnet_comp_asm.h fnet_comp_config.h
    ../../../../fnet_stack/cpu/common/: fnet_fec.c fnet_fec.h
    ../../../../fnet_stack/cpu/mk/: fnet_mk.c fnet_mk.h fnet_mk_cache.c fnet_mk_config.h fnet_mk_eth.c fnet_mk_flash.c fnet_mk_isr.c fnet_mk_isr_inst.c fnet_mk_serial.c fnet_mk_stdlib.c fnet_mk_timer.c fnet_mk60n512_config.h fnet_mk_low.s
    ../../../../fnet_stack/cpu/: fnet_cpu.h fnet_cpu_config.h fnet_cpu.c
    ../../../../fnet_stack/os/: fnet_os.h fnet_os_config.h
    ../../../../fnet_stack/services/dhcp/: fnet_dhcp.c fnet_dhcp.h fnet_dhcp_config.h
    ../../../../fnet_stack/services/dns/: fnet_dns.c fnet_dns.h fnet_dns_config.h
    ../../../../fnet_stack/services/flash/: fnet_flash.c fnet_flash.h
    ../../../../fnet_stack/services/fs/: fnet_fs.c fnet_fs.h fnet_fs_config.h fnet_fs_prv.h fnet_fs_rom.c fnet_fs_rom.h fnet_fs_root.c fnet_fs_root.h
    ../../../../fnet_stack/services/http/: fnet_http.c fnet_http.h fnet_http_auth.c fnet_http_auth.h fnet_http_auth_prv.h fnet_http_cgi.c fnet_http_cgi.h fnet_http_config.h fnet_http_get.c fnet_http_post.c fnet_http_post.h fnet_http_prv.h fnet_http_ssi.c fnet_http_ssi.h fnet_http_ssi_prv.h
    ../../../../fnet_stack/services/poll/: fnet_poll.c fnet_poll.h
    ../../../../fnet_stack/services/serial/: fnet_serial.c fnet_serial.h fnet_serial_config.h
    ../../../../fnet_stack/services/shell/: fnet_shell.c fnet_shell.h fnet_shell_config.h
    ../../../../fnet_stack/services/telnet/: fnet_telnet.c fnet_telnet.h fnet_telnet_config.h
    ../../../../fnet_stack/services/tftp/: fnet_tftp.h fnet_tftp_cln.c fnet_tftp_cln.h fnet_tftp_config.h fnet_tftp_srv.c fnet_tftp_srv.h
    ../../../../fnet_stack/services/: fnet_services.h fnet_services_config.h
    ../../../../fnet_stack/stack/: fnet_arp.c fnet_arp.h fnet_checksum.c fnet_checksum.h fnet_debug.h fnet_error.c fnet_error.h fnet_eth.c fnet_eth.h fnet_eth_prv.h fnet_icmp.c fnet_icmp.h fnet_igmp.c fnet_igmp.h fnet_ip.c fnet_ip.h fnet_ip_prv.h fnet_isr.c fnet_isr.h fnet_loop.c fnet_loop.h fnet_mempool.c fnet_mempool.h fnet_netbuf.c fnet_netbuf.h fnet_netif.c fnet_netif.h fnet_netif_prv.h fnet_prot.c fnet_prot.h fnet_socket.c fnet_socket.h fnet_socket_prv.h fnet_stack.c fnet_stack.h fnet_stack_config.h fnet_stdlib.c fnet_stdlib.h fnet_tcp.c fnet_tcp.h fnet_timer.c fnet_timer.h fnet_timer_prv.h fnet_udp.c fnet_udp.h fnet_ip6.c fnet_ip6.h fnet_ip6_prv.h fnet_nd6.c fnet_nd6.h fnet_inet.c fnet_inet.h fnet_icmp6.c fnet_icmp6.h fnet_raw.c fnet_raw.h fnet_mld.c fnet_mld.h
    ../../../../fnet_stack/: fnet.h fnet_config.h
    ../../../../fnet_stack/services/ping/: fnet_ping.c fnet_ping.h fnet_ping_config.h
  group fnet_application
    ../../../common/fnet_application/: fapp.c fapp.h fapp_bench.c fapp_bench.h fapp_config.h fapp_dhcp.c fapp_dhcp.h fapp_dns.c fapp_dns.h fapp_fs.c fapp_fs.h fapp_fs_image.c fapp_fs_image_http09.c fapp_http.c fapp_http.h fapp_mem.c fapp_mem.h fapp_params.c fapp_params.h fapp_params_prv.h fapp_prv.h fapp_setget.c fapp_setget.h fapp_telnet.c fapp_telnet.h fapp_tftp.c fapp_tftp.h fapp_ping.c fapp_ping.h
  group startup_mk60n512
    ../../../common/startup/startup_mk60n512/: arm_cm4.c arm_cm4.h crt0.s dma_channels.h k60_tower.h start.c start.h sysinit.c sysinit.h vectors.c vectors.h
    ../../../common/startup/startup_mk60n512/common/: common.h startup.c startup.h
    ../../../common/startup/startup_mk60n512/drivers/: mcg.c mcg.h wdog.c wdog.h
    ../../../common/startup/startup_mk60n512/headers/: MK60N512VMD100.h MK60X256VMD100.h regfile.h
  group linker files
    ./Linker Files/: K60N512_FLASH.sct K60N512_RAM.sct
  group src
    ./src/: fnet_user_config.h fapp_user_config.h main.c
target K60N512 - 128KB SRAM (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: shell_intram
  c flags: Optim=4 OneElfS=1
  c define: RAM_TARGET
  c include: as above
  asm define: RAM_TARGET
  asm misc: --cpreproc
  asm include: ..\..\..\..\fnet_stack;..\..\..\..\fnet_stack\compiler;..\..\..\..\fnet_stack\cpu;..\..\..\..\fnet_stack\cpu\common;..\..\..\..\fnet_stack\cpu\mk;..\..\..\..\fnet_stack\os;..\..\..\..\fnet_stack\services;..\..\..\..\fnet_stack\services\dhcp;..\..\..\..\fnet_stack\services\dns;..\..\..\..\fnet_stack\services\flash;..\..\..\..\fnet_stack\services\fs;..\..\..\..\fnet_stack\services\http;..\..\..\..\fnet_stack\services\poll;..\..\..\..\fnet_stack\services\serial;..\..\..\..\fnet_stack\services\shell;..\..\..\..\fnet_stack\services\telnet;..\..\..\..\fnet_stack\services\ping;..\..\..\..\fnet_stack\stack;.\src;..\..\..\common\fnet_application;..\..\..\common\startup\startup_mk60n512;..\..\..\common\startup\startup_mk60n512\common;..\..\..\common\startup\startup_mk60n512\drivers;..\..\..\common\startup\startup_mk60n512\headers;..\..\..\..\fnet_stack\services\tftp
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Linker Files\K60N512_RAM.sct
