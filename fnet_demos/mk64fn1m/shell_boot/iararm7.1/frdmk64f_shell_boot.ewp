# IAR project frdmk64f_shell_boot.ewp, settings and files
configuration FLASH_1MB_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12; IAR
  ICCARM.CCIncludePath2: ..\..\..\common\startup\startup_mk64fn1\CMSIS\Include; ..\..\..\common\startup\startup_mk64fn1\CMSIS\Include\device; ..\..\..\common\startup\startup_mk64fn1\startup\MK64F12; ..\..\..\common\fnet_application; ..\..\..\..\fnet_stack; ..\..\..\..\fnet_stack\compiler; ..\..\..\..\fnet_stack\cpu; ..\..\..\..\fnet_stack\cpu\common; ..\..\..\..\fnet_stack\cpu\mcf; ..\..\..\..\fnet_stack\cpu\mk; ..\..\..\..\fnet_stack\os; ..\..\..\..\fnet_stack\services; ..\..\..\..\fnet_stack\services\dns; ..\..\..\..\fnet_stack\services\dhcp; ..\..\..\..\fnet_stack\services\flash; ..\..\..\..\fnet_stack\services\fs; ..\..\..\..\fnet_stack\services\http; ..\..\..\..\fnet_stack\services\poll; ..\..\..\..\fnet_stack\services\serial; ..\..\..\..\fnet_stack\services\shell; ..\..\..\..\fnet_stack\services\telnet; ..\..\..\..\fnet_stack\services\tftp; ..\..\..\..\fnet_stack\services\ping; ..\..\..\..\fnet_stack\stack; ; src\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: shell_boot_intflash.elf.S19
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config_files/K64FN1Mxxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_1MB_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
configuration RAM_256KB (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config_files/K64FN1Mxxx12_ram.icf
  group (top)
    src/: fapp_user_config.h fnet_user_config.h main.c
  group fnet_application
    ../../../common/fnet_application/: fapp.c fapp.h fapp_bench.c fapp_bench.h fapp_config.h fapp_dhcp.c fapp_dhcp.h fapp_dns.c fapp_dns.h fapp_fs.c fapp_fs.h fapp_fs_image.c fapp_fs_image_http09.c fapp_http.c fapp_http.h fapp_mem.c fapp_mem.h fapp_params.c fapp_params.h fapp_params_prv.h fapp_ping.c fapp_ping.h fapp_prv.h fapp_setget.c fapp_setget.h fapp_telnet.c fapp_telnet.h fapp_tftp.c fapp_tftp.h
  group fnet_stack
    ../../../../fnet_stack/: fnet.h fnet_config.h
  group fnet_stack/compiler
    ../../../../fnet_stack/compiler/: fnet_comp.h fnet_comp_asm.h fnet_comp_config.h
  group fnet_stack/cpu
    ../../../../fnet_stack/cpu/: fnet_cpu.c fnet_cpu.h fnet_cpu_config.h
  group fnet_stack/cpu/common
    ../../../../fnet_stack/cpu/common/: fnet_fec.c fnet_fec.h
  group fnet_stack/cpu/mk
    ../../../../fnet_stack/cpu/mk/: fnet_mk.c fnet_mk.h fnet_mk60fn1_config.h fnet_mk60n512_config.h fnet_mk64fn1_config.h fnet_mk70fn1_config.h fnet_mk_cache.c fnet_mk_config.h fnet_mk_eth.c fnet_mk_flash.c fnet_mk_isr.c fnet_mk_isr_inst.c fnet_mk_low.s fnet_mk_serial.c fnet_mk_stdlib.c fnet_mk_timer.c
  group fnet_stack/os
    ../../../../fnet_stack/os/: fnet_os.h fnet_os_config.h
  group fnet_stack/services/dhcp
    ../../../../fnet_stack/services/dhcp/: fnet_dhcp.c fnet_dhcp.h fnet_dhcp_config.h
  group fnet_stack/services/dns
    ../../../../fnet_stack/services/dns/: fnet_dns.c fnet_dns.h fnet_dns_config.h
  group fnet_stack/services/flash
    ../../../../fnet_stack/services/flash/: fnet_flash.c fnet_flash.h
  group fnet_stack/services/fs
    ../../../../fnet_stack/services/fs/: fnet_fs.c fnet_fs.h fnet_fs_config.h fnet_fs_prv.h fnet_fs_rom.c fnet_fs_rom.h fnet_fs_root.c fnet_fs_root.h
  group fnet_stack/services/http
    ../../../../fnet_stack/services/http/: fnet_http.c fnet_http.h fnet_http_auth.c fnet_http_auth.h fnet_http_auth_prv.h fnet_http_cgi.c fnet_http_cgi.h fnet_http_config.h fnet_http_get.c fnet_http_post.c fnet_http_post.h fnet_http_prv.h fnet_http_ssi.c fnet_http_ssi.h fnet_http_ssi_prv.h
  group fnet_stack/services/ping
    ../../../../fnet_stack/services/ping/: fnet_ping.c fnet_ping.h fnet_ping_config.h
  group fnet_stack/services/poll
    ../../../../fnet_stack/services/poll/: fnet_poll.c fnet_poll.h
  group fnet_stack/services/serial
    ../../../../fnet_stack/services/serial/: fnet_serial.c fnet_serial.h fnet_serial_config.h
  group fnet_stack/services/shell
    ../../../../fnet_stack/services/shell/: fnet_shell.c fnet_shell.h fnet_shell_config.h
  group fnet_stack/services/telnet
    ../../../../fnet_stack/services/telnet/: fnet_telnet.c fnet_telnet.h fnet_telnet_config.h
  group fnet_stack/services/tftp
    ../../../../fnet_stack/services/tftp/: fnet_tftp.h fnet_tftp_cln.c fnet_tftp_cln.h fnet_tftp_config.h fnet_tftp_srv.c fnet_tftp_srv.h
  group fnet_stack/stack
    ../../../../fnet_stack/stack/: fnet_arp.c fnet_arp.h fnet_checksum.c fnet_checksum.h fnet_debug.h fnet_error.c fnet_error.h fnet_eth.c fnet_eth.h fnet_eth_prv.h fnet_icmp.c fnet_icmp.h fnet_icmp6.c fnet_icmp6.h fnet_igmp.c fnet_igmp.h fnet_inet.c fnet_inet.h fnet_ip.c fnet_ip.h fnet_ip6.c fnet_ip6.h fnet_ip6_prv.h fnet_ip_prv.h fnet_isr.c fnet_isr.h fnet_loop.c fnet_loop.h fnet_mempool.c fnet_mempool.h fnet_mld.c fnet_mld.h fnet_nd6.c fnet_nd6.h fnet_netbuf.c fnet_netbuf.h fnet_netif.c fnet_netif.h fnet_netif_prv.h fnet_prot.c fnet_prot.h fnet_raw.c fnet_raw.h fnet_socket.c fnet_socket.h fnet_socket_prv.h fnet_stack.c fnet_stack.h fnet_stack_config.h fnet_stdlib.c fnet_stdlib.h fnet_tcp.c fnet_tcp.h fnet_timer.c fnet_timer.h fnet_timer_prv.h fnet_udp.c fnet_udp.h
  group startup
    ../../../common/startup/startup_mk64fn1/startup/: startup.c startup.h
    ../../../common/startup/startup_mk64fn1/startup/MK64F12/iar/: startup_MK64F12.s
    ../../../common/startup/startup_mk64fn1/startup/MK64F12/: system_MK64F12.c system_MK64F12.h
